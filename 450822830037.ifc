Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-07-11T18:20:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 11 18:20:49 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{83E111FF-BF03-47B2-A617-8A3B979CEF06}\ifc * Database version: 5507 * Database creation date: Thu Jul 11 18:20:48 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 11 18:20:48 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 11 18:20:48 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 450822830037 Kitchen faucet, 450822830037:450822830037 Kitchen faucet:408454
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 15 mm; NominalDepth: 250.948 mm; NominalHeight: 177.519 mm; NominalWidth: 53 mm; Projection: 211 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 450822830037; ConvergoRefNr: 0087-1909-0015-FI; ManufacterURL: http://www.hansa.com/; ManufacturerName: Hansa; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 05/07/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 4057304004339; EN Standard: EN 817; Noise Class: I (ISO 3822) Oras lab.
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.hansa.com/bim/450822830037; Catalog Drawing URL: http://static.hansa.com/catdrw/450822830037; Class: Single lever; Dimension Drawing URL: http://static.hansa.com/dimdrw/450822830037; FDV Document URL: http://www.hansa.com/datasheet/450822830037/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/450822830037; Group: Kitchen faucets; Manufacturer: Hansa; Market: INT;AUS; Model: 450822830037 Kitchen faucet; Name_en: 450822830037 Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 362 x 278 x 63; Package Weight: 2.34 kg; Product Code: 450822830037; Product Datasheet: http://www.hansa.com/datasheet/450822830037/en; Product Family: HANSAPINTO; Product Image URL: http://static.hansa.com/image/450822830037; Product URL: http://static.hansa.com/450822830037; Type Name: 450822830037 Kitchen faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Connection: Flexible Inlet Pipes; Connection Size: G1/2; DN Size: DN15; Flow Rate At 300kPa: 0.00459091 m3/s; Installation and Maintenance: http://static.hansa.com/manual/450822830037; Installation Type: Deck mounted; Lever Handle: Lever with H+C symbol; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 Mounting Hole; Spare Parts: http://static.hansa.com/sp/450822830037; Spout Swivel Range: 120° (80° / 40°); Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Hansa; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 450822830037; Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 450822830037; Name: 450822830037 Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 55x250x180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 450822830037; Manufacturer: Hansa
Pset_DistributionFlowElementCommon - Reference: 450822830037 Kitchen faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0690241 m2; Volume: 0.00237166 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 450822830037: 450822830037 Kitchen faucet; Family and Type: 450822830037: 450822830037 Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 450822830037: 450822830037 Kitchen faucet; Type Id: 450822830037: 450822830037 Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
